# Keil uVision project utils_test.uvproj, settings and files
target DEBUG (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2368 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: utils_test
  c flags: Optim=1 OneElfS=1
  c define: __DEBUG__
  c misc: --c99
  c include: D:\HX_UTILS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group test
    ./: Startup.s main.c
  group HX_UTILS
    ../: hx_debug.c hx_device.c hx_term.c hx_term_cmds.c hx_utils.c hx_ver_def.c hxd_uart.c hxl_serial.c jlink_dcc.c me3630.c mg3732.c ne4110s.c rak415.c sim800c.c sim7100c.c sim7600c.c hxd_param.c hxd_atc.c
    ../cpu/: cpu_lpc2378.c
    ../board/: brd_dq1200.c
